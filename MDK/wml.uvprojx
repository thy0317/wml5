# Keil uVision project wml.uvprojx, settings and files
target wml-4 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: wml
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Libraries;..\Libraries\inc;..\Libraries\CMSIS
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group app
    ../Applications/: main.c key.c do.c
  group lib
    ../Libraries/: system_stm32f10x.c stm32f10x_it.c startup_stm32f10x_md.s
    ../Libraries/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c
